# Keil uVision project Insulator_Robot.uvprojx, settings and files
target Insulator_Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Insulator_Robot
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\HARDWARE\DMA;..\HARDWARE\LED;..\HARDWARE\TIMER;..\CORE;..\HARDWARE\CAN
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_flash.c
  group Hardware
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAN/: can.c
    ./: pid.c chassispid.c timer7.c encoder.c flash.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./: jetson.c
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c my_sin.c
